# Keil uVision project Project.uvprojx, settings and files
target STM32F334R8-Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00003000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F334R8-Nucleo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=$l@L.bin !L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F334x8,USE_HAL_DRIVER,USE_STM32F3XX_NUCLEO
  c misc: --C99
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\..\..\..\..\..\..\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM32F3xx-Nucleo;..\..\..\..\..\..\..\Drivers\BSP\Components\powerstep01;..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHMxx;..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --diag_suppress=L6329
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components/powerstep01
    ../../../../../../../Drivers/BSP/Components/powerstep01/: powerstep01.c
  group Drivers/BSP/X-NUCLEO-IHMxx
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHMxx/: x_nucleo_ihmxx.c
  group Drivers/BSP/STM32F3xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F3xx-Nucleo/: stm32f3xx_nucleo.c
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHMxx/: x_nucleo_ihm03a1_stm32f3xx.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../../../../../../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_dma.c stm32f3xx_hal_adc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f334x8.s
  group Example/User
    ../../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c clock_f3.c
software components: CMSIS:CORE 4.3.0
