# IAR project Project.ewp, settings and files
configuration IHM03A1_ExampleFor1Motor_STM32L053R8-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx; USE_STM32L0XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IHMxx; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\Components\powerstep01
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EWARM-IHM03A1-STM32L0xx-Nucleo-ExampleFor1Motor.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components/powerstep01
    ../../../../../../../Drivers/BSP/Components/powerSTEP01/: powerstep01.c
  group Drivers/BSP/MotorControl
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHMxx/: x_nucleo_ihmxx.c
  group Drivers/BSP/STM32L0xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
    ../../../../../../../Drivers/BSP/X-NUCLEO-IHMxx/: x_nucleo_ihm03a1_stm32l0xx.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Example/EWARM
    ./: startup_stm32l053xx.s
  group Example/User
    ../../Src/: clock_l0.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
